# Keil uVision project Point-To-Point.uvprojx, settings and files
target S2LP_STM32L053R8_Nucleo (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Point-To-Point
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STM32L0XX_NUCLEO,USE_STDPERIPH_DRIVER,STM32L0,USE_HAL_DRIVER,STM32L053xx,USE_SYSTICK_DELAY,S2LP_SUPPORT,X_NUCLEO_S2868A1,USE_S2_LP_DEFAULT
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Projects/Multi/Examples/P2P_demo/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/USER
    ../Src/: cube_hal_l0.c main.c radio_appli.c s2lp_interface.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Driver/BSP/Components/S2LP/S2LP_Library
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Driver/BSP/Components/S2LP/S2LP_Util
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Driver/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Driver/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Driver/CMSIS
    ../Src/: system_stm32l0xx.c
  group Driver/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_usart.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dma.c
software components: CMSIS:CORE 4.3.0
