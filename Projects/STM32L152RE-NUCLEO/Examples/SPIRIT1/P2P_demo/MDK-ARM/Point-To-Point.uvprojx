# Keil uVision project Point-To-Point.uvprojx, settings and files
target SPIRIT1_STM32L152RE_Nucleo (ARM-ADS)
  device: STM32L152ZE STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Point-To-Point
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER,STM32L152xE,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32L1,NO_EEPROM,X_NUCLEO_IDS01A4,USE_STDPERIPH_DRIVER,USE_SYSTICK_DELAY
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/USER
    ../Src/: cube_hal_l1.c main.c radio_appli.c stm32l1xx_it.c
  group Doc
    ../: readme.txt
  group Driver/BSP/Components/SPIRIT1/spirit1_library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Driver/BSP/Components/SPIRIT1/Spirit1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Driver/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Driver/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Driver/CMSIS
    ../Src/: system_stm32l1xx.c
  group Driver/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
